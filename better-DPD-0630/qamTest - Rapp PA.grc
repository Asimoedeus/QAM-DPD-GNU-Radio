options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: QAM
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    comment: '[excessive bandwidth] for cosine filter'
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: The [number] of [Synchronized Filter Bank]
    value: '32'
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: rrc_taps_sync
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 采样率（32ksps）
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: The [number of samples] for every symbol
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam16
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0_1_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps_sync
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    A_sat: '1.0'
    _source_code: |
      """
      Embedded Python Blocks:
       
      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block"
          """
          Simple Rapp model PA:
              y = x / (1 + (|x|/A_sat)^(2*p))^(1/(2*p))
          When p → ∞ 就变成硬限幅；p 越小转折越圆滑
          """
          def __init__(self, A_sat=1.0, p=2.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PA_model_Rapp',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.A_sat = A_sat
              self.p = p

          def work(self, input_items, output_items):
              x = input_items[0]
              y = x / (1.0 + (np.abs(x)/self.A_sat)**(2.0*self.p))**(1.0/(2.0*self.p))
              output_items[0][:] = y
              return len(output_items[0])
    p: '3'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import torch
      from gnuradio import gr
      import torch.nn as nn

      class DGRU(nn.Module):
          def __init__(self, hidden_size, output_size, num_layers, bidirectional=False, batch_first=True,
                       bias=True):
              super(DGRU, self).__init__()
              self.hidden_size = hidden_size
              self.input_size = 6
              self.output_size = output_size
              self.num_layers = num_layers
              self.bidirectional = bidirectional
              self.batch_first = batch_first
              self.bias = bias

              # Instantiate NN Layers
              self.rnn = nn.GRU(input_size=self.input_size,
                                hidden_size=hidden_size,
                                num_layers=num_layers,
                                bidirectional=self.bidirectional,
                                batch_first=self.batch_first,
                                bias=self.bias)
              self.fc_out = nn.Linear(in_features=hidden_size + self.input_size,
                                      out_features=self.output_size,
                                      bias=self.bias)
              self.fc_hid = nn.Linear(in_features=hidden_size,
                                      out_features=hidden_size,
                                      bias=self.bias)

          def reset_parameters(self):
              for name, param in self.rnn.named_parameters():
                  num_gates = int(param.shape[0] / self.hidden_size)
                  if 'bias' in name:
                      nn.init.constant_(param, 0)
                  if 'weight' in name:
                      for i in range(0, num_gates):
                          nn.init.orthogonal_(param[i * self.hidden_size:(i + 1) * self.hidden_size, :])
                  if 'weight_ih_l0' in name:
                      for i in range(0, num_gates):
                          nn.init.xavier_uniform_(param[i * self.hidden_size:(i + 1) * self.hidden_size, :])

              for name, param in self.fc_out.named_parameters():
                  if 'weight' in name:
                      nn.init.xavier_uniform_(param)
                  if 'bias' in name:
                      nn.init.constant_(param, 0)

              for name, param in self.fc_hid.named_parameters():
                  if 'weight' in name:
                      nn.init.kaiming_uniform_(param)
                  if 'bias' in name:
                      nn.init.constant_(param, 0)

          def forward(self, x, h_0):
              # Feature Extraction
              i_x = torch.unsqueeze(x[..., 0], dim=-1)
              q_x = torch.unsqueeze(x[..., 1], dim=-1)
              amp2 = torch.pow(i_x, 2) + torch.pow(q_x, 2)
              amp = torch.sqrt(amp2)
              amp3 = torch.pow(amp, 3)
              cos = i_x / amp
              sin = q_x / amp
              x = torch.cat((i_x, q_x, amp, amp3, sin, cos), dim=-1)
              # Regressor
              out, _ = self.rnn(x, h_0)
              out = torch.relu(self.fc_hid(out))
              out = torch.cat((out, x), dim=-1)
              out = self.fc_out(out)
              return out
              
      class CoreModel(nn.Module):
          def __init__(self, input_size, hidden_size, num_layers, backbone_type, window_size=None, num_dvr_units=None, thx=0, thh=0):
              super(CoreModel, self).__init__()
              self.output_size = 2  # PA outputs: I & Q
              self.input_size = input_size
              self.hidden_size = hidden_size
              self.num_layers = num_layers
              self.backbone_type = backbone_type
              self.thx = thx
              self.thh = thh
              self.window_size = window_size
              self.num_dvr_units = num_dvr_units
              self.batch_first = True  # Force batch first
              self.bidirectional = False
              self.bias = True

              if backbone_type == 'dgru':
                 # from backbones.dgru import DGRU
                 self.backbone = DGRU(hidden_size=self.hidden_size,
                                      output_size=self.output_size,
                                      num_layers=self.num_layers,
                                      bidirectional=self.bidirectional,
                                      batch_first=self.batch_first,
                                      bias=self.bias)
              else:
                  raise ValueError(f"The backbone type '{self.backbone_type}' is not supported. Please add your own "
                                   f"backbone under ./backbones and update models.py accordingly.")

              # Initialize backbone parameters
              try:
                  self.backbone.reset_parameters()
                  print("Backbone Initialized...")
              except AttributeError:
                  pass

          def forward(self, x, h_0=None):
              device = x.device
              batch_size = x.size(0)  # NOTE: dim of x must be (batch, time, feat)/(N, T, F)

              if h_0 is None:  # Create initial hidden states if necessary
                  h_0 = torch.zeros(self.num_layers, batch_size, self.hidden_size).to(device)

              # Forward Propagate through the RNN
              out = self.backbone(x, h_0)

              return out

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          """Apply DPD model to input complex samples"""
          def __init__(self, model_path='C:\Programming\pythonProjects\QAM-In-GNU-Radio-main\Rapp_PA_GNU-Radio\DPD_S_0_M_DGRU_H_15_F_200_P_1319.pt'):
              gr.sync_block.__init__(
                  self,
                  name='DPD_model',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              model_path = 'C:\Programming\pythonProjects\QAM-In-GNU-Radio-main\Rapp_PA_GNU-Radio\DPD_S_0_M_DGRU_H_15_F_200_P_1319.pt'
              self.model_path = model_path
              self.device = torch.device('cuda' if torch.cuda.is_available() else 'cpu')

              # Instantiate network with known architecture
              self.net = CoreModel(
                  input_size=2,
                  hidden_size=15,
                  num_layers=1,
                  backbone_type='dgru'
              )
              # Load pretrained parameters
              state_dict = torch.load(self.model_path, map_location=self.device)
              self.net.load_state_dict(state_dict)
              self.net.eval()
              self.net.to(self.device)

          def work(self, input_items, output_items):
              x = input_items[0]
              # Convert complex data to (N, 2) real-imag tensor
              x_np = np.vstack((x.real, x.imag)).T.astype(np.float32)
              x_tensor = torch.from_numpy(x_np).unsqueeze(0).to(self.device)
              with torch.no_grad():
                  y = self.net(x_tensor).cpu().numpy()[0]
              output_items[0][:] = y[:, 0] + 1j * y[:, 1]
              return len(output_items[0])
    model_path: '''C:\Programming\pythonProjects\QAM-In-GNU-Radio-main\Rapp_PA_GNU-Radio\DPD_S_0_M_DGRU_H_15_F_200_P_1319.pt'''
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: ''
    label2: ''
    name: '"QAM16"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_mag_1, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0_0_0_0, '0', digital_pfb_clock_sync_xxx_0_1_0, '0']
- [blocks_throttle_0_0_0_0, '0', fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_complex_to_mag_1, '0']
- [digital_constellation_modulator_0_0_0_0, '0', epy_block_1, '0']
- [digital_pfb_clock_sync_xxx_0_1_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [epy_block_0, '0', blocks_complex_to_mag_0, '0']
- [epy_block_0, '0', blocks_throttle_0_0_0_0, '0']
- [epy_block_1, '0', epy_block_0, '0']
- [fir_filter_xxx_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
