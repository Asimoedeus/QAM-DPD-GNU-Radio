options:
  parameters:
    author: Surface-Li
    generate_options: qt_gui
    id: GMP_PA_gnuradio
    output_language: python
    title: GMP_PA
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    comment: '[excessive bandwidth] for cosine filter'
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: The [number] of [Synchronized Filter Bank]
    value: '32'
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: rrc_taps_sync
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    comment: 采样率（32ksps）
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: The [number of samples] for every symbol
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '16384'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: input of PA
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    comment: output of PA
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: GMP_PA_output
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: GMP_PA_input
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '65535'
    type: complex
  states: {state: disabled}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: '65535'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam16
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0_1_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps_sync
    type: ccf
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class PA_model_GMP(gr.sync_block):
          """
          Generalized Memory Polynomial (GMP) PA Model Block.

          This block implements a GMP model defined by the equation:
          y[n] = sum_{k=1 to K} sum_{q=0 to Q} a_kq * x[n-q] * |x[n-q]|^{k-1}

          The coefficients 'a_kq' are provided as a 2D list or numpy array.
          """
          def __init__(self, coeffs= [
          [0.95+0.01j, 0.05-0.02j],  # k=1: a_10, a_11 (线性项和记忆项)
          [0.00-0.00j, 0.00+0.00j],  # k=2: a_20, a_21 (主要引起AM/PM)
          [-0.1-0.08j, -0.02-0.01j]  # k=3: a_30, a_31 (主要引起AM/AM)
      ]):
              """
              Args:
                  coeffs (list or numpy.ndarray): A 2D array-like structure for the
                      complex coefficients a_kq. The shape should be K x (Q+1).
                      Example: [[a_10, a_11], [a_20, a_21], [a_30, a_31]]
                      for K=3, Q=1.
              """
              gr.sync_block.__init__(
                  self,
                  name='PA_model_GMP',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              # --- 从系数矩阵中推导模型参数 ---
              self.coeffs = np.array(coeffs, dtype=np.complex64)
              if self.coeffs.ndim != 2:
                  raise ValueError("Coefficients must be a 2D array-like object.")

              # K is the number of rows (non-linearity order)
              # Q is (number of columns - 1) (memory depth)
              self.K = self.coeffs.shape[0]
              self.Q = self.coeffs.shape[1] - 1
              
              if self.Q < 0:
                  raise ValueError("Coefficients matrix must have at least one column.")

              # --- 初始化用于存储历史样本的状态变量 ---
              # self.history stores the last Q input samples for memory effects.
              self.history = np.zeros(self.Q, dtype=np.complex64)

          def work(self, input_items, output_items):
              # input_items[0] is the new block of input samples
              # output_items[0] is where we write our output samples
              x_new = input_items[0]
              y_out = output_items[0]
              
              # --- 核心处理逻辑 ---

              # 1. 将历史样本与新输入样本拼接，形成一个完整的工作向量
              #    This allows us to compute y[n] which depends on x[n-q]
              x_full = np.concatenate((self.history, x_new))
              
              # 获取新输入的长度
              num_new_samples = len(x_new)
              
              # 初始化输出为零
              # The output is a summation, so we start with zeros.
              y_out[:] = 0.0

              # 2. 执行GMP双重求和计算
              # Outer loop over non-linearity order k (from 1 to K)
              for k_idx in range(self.K):
                  k = k_idx + 1 # k runs from 1 to K
                  # Inner loop over memory depth q (from 0 to Q)
                  for q in range(self.Q + 1):
                      # 获取系数 a_kq
                      a_kq = self.coeffs[k_idx, q]
                      
                      # 获取带有延迟的输入信号 x[n-q]
                      # For an output block of size N, the corresponding input
                      # slice from x_full is x_full[Q-q : Q-q+N]
                      delayed_input = x_full[self.Q - q : self.Q - q + num_new_samples]
                      
                      # 计算当前项并累加到输出
                      # term = a_kq * x[n-q] * |x[n-q]|^{k-1}
                      term = a_kq * delayed_input * (np.abs(delayed_input)**(k - 1))
                      y_out[:] += term

              # 3. 更新历史记录，为下一次调用work做好准备
              # The last Q samples of the full input vector become the new history.
              self.history = x_full[-self.Q:] if self.Q > 0 else np.array([])
              
              # 4. 返回处理的样本数
              return len(y_out)
    coeffs: '[[0.95+0.01j, 0.05-0.02j],[0.00-0.00j, 0.00+0.00j],[-0.1-0.08j, -0.02-0.01j]]'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import torch
      from gnuradio import gr
      import torch.nn as nn

      class DGRU(nn.Module):
          def __init__(self, hidden_size, output_size, num_layers, bidirectional=False, batch_first=True,
                       bias=True):
              super(DGRU, self).__init__()
              self.hidden_size = hidden_size
              self.input_size = 6
              self.output_size = output_size
              self.num_layers = num_layers
              self.bidirectional = bidirectional
              self.batch_first = batch_first
              self.bias = bias

              # Instantiate NN Layers
              self.rnn = nn.GRU(input_size=self.input_size,
                                hidden_size=hidden_size,
                                num_layers=num_layers,
                                bidirectional=self.bidirectional,
                                batch_first=self.batch_first,
                                bias=self.bias)
              self.fc_out = nn.Linear(in_features=hidden_size + self.input_size,
                                      out_features=self.output_size,
                                      bias=self.bias)
              self.fc_hid = nn.Linear(in_features=hidden_size,
                                      out_features=hidden_size,
                                      bias=self.bias)

          def reset_parameters(self):
              for name, param in self.rnn.named_parameters():
                  num_gates = int(param.shape[0] / self.hidden_size)
                  if 'bias' in name:
                      nn.init.constant_(param, 0)
                  if 'weight' in name:
                      for i in range(0, num_gates):
                          nn.init.orthogonal_(param[i * self.hidden_size:(i + 1) * self.hidden_size, :])
                  if 'weight_ih_l0' in name:
                      for i in range(0, num_gates):
                          nn.init.xavier_uniform_(param[i * self.hidden_size:(i + 1) * self.hidden_size, :])

              for name, param in self.fc_out.named_parameters():
                  if 'weight' in name:
                      nn.init.xavier_uniform_(param)
                  if 'bias' in name:
                      nn.init.constant_(param, 0)

              for name, param in self.fc_hid.named_parameters():
                  if 'weight' in name:
                      nn.init.kaiming_uniform_(param)
                  if 'bias' in name:
                      nn.init.constant_(param, 0)

          def forward(self, x, h_0):
              # Feature Extraction
              i_x = torch.unsqueeze(x[..., 0], dim=-1)
              q_x = torch.unsqueeze(x[..., 1], dim=-1)
              amp2 = torch.pow(i_x, 2) + torch.pow(q_x, 2)
              amp = torch.sqrt(amp2)
              amp3 = torch.pow(amp, 3)
              cos = i_x / amp
              sin = q_x / amp
              x = torch.cat((i_x, q_x, amp, amp3, sin, cos), dim=-1)
              # Regressor
              out, _ = self.rnn(x, h_0)
              out = torch.relu(self.fc_hid(out))
              out = torch.cat((out, x), dim=-1)
              out = self.fc_out(out)
              return out
              
      class CoreModel(nn.Module):
          def __init__(self, input_size, hidden_size, num_layers, backbone_type, window_size=None, num_dvr_units=None, thx=0, thh=0):
              super(CoreModel, self).__init__()
              self.output_size = 2  # PA outputs: I & Q
              self.input_size = input_size
              self.hidden_size = hidden_size
              self.num_layers = num_layers
              self.backbone_type = backbone_type
              self.thx = thx
              self.thh = thh
              self.window_size = window_size
              self.num_dvr_units = num_dvr_units
              self.batch_first = True  # Force batch first
              self.bidirectional = False
              self.bias = True

              if backbone_type == 'dgru':
                 # from backbones.dgru import DGRU
                 self.backbone = DGRU(hidden_size=self.hidden_size,
                                      output_size=self.output_size,
                                      num_layers=self.num_layers,
                                      bidirectional=self.bidirectional,
                                      batch_first=self.batch_first,
                                      bias=self.bias)
              else:
                  raise ValueError(f"The backbone type '{self.backbone_type}' is not supported. Please add your own "
                                   f"backbone under ./backbones and update models.py accordingly.")

              # Initialize backbone parameters
              try:
                  self.backbone.reset_parameters()
                  print("Backbone Initialized...")
              except AttributeError:
                  pass

          def forward(self, x, h_0=None):
              device = x.device
              batch_size = x.size(0)  # NOTE: dim of x must be (batch, time, feat)/(N, T, F)

              if h_0 is None:  # Create initial hidden states if necessary
                  h_0 = torch.zeros(self.num_layers, batch_size, self.hidden_size).to(device)

              # Forward Propagate through the RNN
              out = self.backbone(x, h_0)

              return out

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          """Apply DPD model to input complex samples"""
          def __init__(self, model_path='C:/Programming/pythonProjects/OpenDPD-main/save/GMP_PA/train_dpd/PA_S_0_M_DGRU_H_23_F_200/DPD_S_0_M_DGRU_H_15_F_200_P_1319.pt'):
              gr.sync_block.__init__(
                  self,
                  name='DPD_model',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # model_path = 'C:\Programming\pythonProjects\QAM-In-GNU-Radio-main\Rapp_PA_GNU-Radio\DPD_S_0_M_DGRU_H_15_F_200_P_1319.pt'
              self.model_path = model_path
              self.device = torch.device('cuda' if torch.cuda.is_available() else 'cpu')

              # Instantiate network with known architecture
              self.net = CoreModel(
                  input_size=2,
                  hidden_size=15,
                  num_layers=1,
                  backbone_type='dgru'
              )
              # Load pretrained parameters
              state_dict = torch.load(self.model_path, map_location=self.device)
              self.net.load_state_dict(state_dict)
              self.net.eval()
              self.net.to(self.device)

          def work(self, input_items, output_items):
              x = input_items[0]
              # Convert complex data to (N, 2) real-imag tensor
              x_np = np.vstack((x.real, x.imag)).T.astype(np.float32)
              x_tensor = torch.from_numpy(x_np).unsqueeze(0).to(self.device)
              with torch.no_grad():
                  y = self.net(x_tensor).cpu().numpy()[0]
              output_items[0][:] = y[:, 0] + 1j * y[:, 1]
              return len(output_items[0])
    model_path: '''C:/Programming/pythonProjects/OpenDPD-main/save/GMP_PA/train_dpd/PA_S_0_M_DGRU_H_23_F_200/DPD_S_0_M_DGRU_H_15_F_200_P_1319.pt'''
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: AM/AM
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: ''
    label2: ''
    name: '"QAM16"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_1, '0']
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0_0_0_0, '0', digital_pfb_clock_sync_xxx_0_1_0, '0']
- [blocks_throttle_0_0_0_0, '0', fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_head_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', epy_block_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_1_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [epy_block_1, '0', blocks_complex_to_mag_1, '0']
- [epy_block_1, '0', blocks_head_1, '0']
- [epy_block_1, '0', blocks_throttle_0_0_0_0, '0']
- [epy_block_1_0, '0', blocks_complex_to_mag_0, '0']
- [epy_block_1_0, '0', epy_block_1, '0']
- [fir_filter_xxx_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
