options:
  parameters:
    author: LI
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    comment: '[excessive bandwidth] for cosine filter'
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: The [number] of [Synchronized Filter Bank]
    value: '32'
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: rrc_taps_sync
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: The [number of samples] for every symbol
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '16384'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1.5'
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam16
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0_1_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps_sync
    type: ccf
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class PA_model_GMP(gr.sync_block):
          """
          Generalized Memory Polynomial (GMP) PA Model Block.

          This block implements a GMP model defined by the equation:
          y[n] = sum_{k=1 to K} sum_{q=0 to Q} a_kq * x[n-q] * |x[n-q]|^{k-1}

          The coefficients 'a_kq' are provided as a 2D list or numpy array.
          """
          def __init__(self, coeffs= [
          [0.95+0.01j, 0.05-0.02j],  # k=1: a_10, a_11 (线性项和记忆项)
          [0.00-0.00j, 0.00+0.00j],  # k=2: a_20, a_21 (主要引起AM/PM)
          [-0.1-0.08j, -0.02-0.01j]  # k=3: a_30, a_31 (主要引起AM/AM)
      ]):
              """
              Args:
                  coeffs (list or numpy.ndarray): A 2D array-like structure for the
                      complex coefficients a_kq. The shape should be K x (Q+1).
                      Example: [[a_10, a_11], [a_20, a_21], [a_30, a_31]]
                      for K=3, Q=1.
              """
              gr.sync_block.__init__(
                  self,
                  name='PA_model_GMP',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              # --- 从系数矩阵中推导模型参数 ---
              self.coeffs = np.array(coeffs, dtype=np.complex64)
              if self.coeffs.ndim != 2:
                  raise ValueError("Coefficients must be a 2D array-like object.")

              # K is the number of rows (non-linearity order)
              # Q is (number of columns - 1) (memory depth)
              self.K = self.coeffs.shape[0]
              self.Q = self.coeffs.shape[1] - 1
              
              if self.Q < 0:
                  raise ValueError("Coefficients matrix must have at least one column.")

              # --- 初始化用于存储历史样本的状态变量 ---
              # self.history stores the last Q input samples for memory effects.
              self.history = np.zeros(self.Q, dtype=np.complex64)

          def work(self, input_items, output_items):
              # input_items[0] is the new block of input samples
              # output_items[0] is where we write our output samples
              x_new = input_items[0]
              y_out = output_items[0]
              
              # --- 核心处理逻辑 ---

              # 1. 将历史样本与新输入样本拼接，形成一个完整的工作向量
              #    This allows us to compute y[n] which depends on x[n-q]
              x_full = np.concatenate((self.history, x_new))
              
              # 获取新输入的长度
              num_new_samples = len(x_new)
              
              # 初始化输出为零
              # The output is a summation, so we start with zeros.
              y_out[:] = 0.0

              # 2. 执行GMP双重求和计算
              # Outer loop over non-linearity order k (from 1 to K)
              for k_idx in range(self.K):
                  k = k_idx + 1 # k runs from 1 to K
                  # Inner loop over memory depth q (from 0 to Q)
                  for q in range(self.Q + 1):
                      # 获取系数 a_kq
                      a_kq = self.coeffs[k_idx, q]
                      
                      # 获取带有延迟的输入信号 x[n-q]
                      # For an output block of size N, the corresponding input
                      # slice from x_full is x_full[Q-q : Q-q+N]
                      delayed_input = x_full[self.Q - q : self.Q - q + num_new_samples]
                      
                      # 计算当前项并累加到输出
                      # term = a_kq * x[n-q] * |x[n-q]|^{k-1}
                      term = a_kq * delayed_input * (np.abs(delayed_input)**(k - 1))
                      y_out[:] += term

              # 3. 更新历史记录，为下一次调用work做好准备
              # The last Q samples of the full input vector become the new history.
              self.history = x_full[-self.Q:] if self.Q > 0 else np.array([])
              
              # 4. 返回处理的样本数
              return len(y_out)
    coeffs: '[[1.50+0.01j, 0.05-0.02j],[0.00-0.00j, 0.00+0.00j],[-0.1-0.08j, -0.02-0.01j]]'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python block for ARVTDNN DPD model inference in GNU Radio
      """
      import numpy as np
      import torch
      import torch.nn as nn
      from gnuradio import gr

      class ARVTDNN(nn.Module):
          def __init__(self, input_dim, hidden_dims=[128, 64]):
              super(ARVTDNN, self).__init__()
              layers = []
              prev = input_dim
              for h in hidden_dims:
                  layers.append(nn.Linear(prev, h))
                  layers.append(nn.ReLU())
                  prev = h
              layers.append(nn.Linear(prev, 2))  # 输出 I/Q
              self.net = nn.Sequential(*layers)

          def forward(self, x):
              return self.net(x)


      def extract_features(x, memory=3, order=3, order_memory=2):
          """
          构建 ARVTDNN 特征：延迟 I/Q + 幅度多项式
          """
          N = len(x) - memory
          feat_dim = (memory + 1) * 2 + (order - 1) * (order_memory + 1)
          feats = np.zeros((N, feat_dim), dtype=np.float32)
          for n in range(N):
              idx = 0
              # 时滞 I/Q
              for m in range(memory + 1):
                  feats[n, idx] = x[n + m].real; idx += 1
                  feats[n, idx] = x[n + m].imag; idx += 1
              # 幅度多项式
              for m in range(order_memory + 1):
                  amp = np.abs(x[n + m])
                  for k in range(2, order + 1):
                      feats[n, idx] = amp**k; idx += 1
          return feats

      class blk(gr.sync_block):
          """ARVTDNN DPD Model Block"""
          def __init__(self, model_path="C:\Programming\pythonProjects\QAM-In-GNU-Radio-main\ILA\dpd_model.pth", memory=3, order=3, order_memory=2, scale=1.0):
              gr.sync_block.__init__(self,
                  name="ARVTDNN_DPD",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              self.model_path = model_path
              self.memory = memory
              self.order = order
              self.order_memory = order_memory
              self.scale = scale
              self.device = torch.device('cpu')

              # 加载模型
              input_dim = (self.memory + 1) * 2 + (self.order - 1) * (self.order_memory + 1)
              self.net = ARVTDNN(input_dim).to(self.device)
              state = torch.load(self.model_path, map_location=self.device)
              self.net.load_state_dict(state)
              self.net.eval()

              # 保留历史样本
              self.buf = np.zeros(self.memory, dtype=np.complex64)

          def work(self, input_items, output_items):
              x_in = input_items[0]
              N = len(x_in)
              # 拼接历史与当前
              x = np.concatenate((self.buf, x_in)).astype(np.complex64)
              # 归一化
              x_norm = x / self.scale
              # 特征提取
              feats = extract_features(x_norm, self.memory, self.order, self.order_memory)
              # 推断
              with torch.no_grad():
                  tensor = torch.from_numpy(feats).to(self.device)
                  pred = self.net(tensor).cpu().numpy()
              # 重构复信号
              dpd = (pred[:, 0] + 1j * pred[:, 1]) * self.scale
              y = dpd.astype(np.complex64)
              # 输出并更新历史
              output_items[0][:] = y
              self.buf = x_in[-self.memory:]
              return N
    memory: '3'
    model_path: '''C:/Programming/pythonProjects/QAM-In-GNU-Radio-main/ILA/dpd_model.pth'''
    order: '3'
    order_memory: '2'
    scale: '1.0'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,1,1
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_throttle_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', digital_pfb_clock_sync_xxx_0_1_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', epy_block_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_1_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [epy_block_1, '0', blocks_multiply_const_xx_0, '0']
- [epy_block_1_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
